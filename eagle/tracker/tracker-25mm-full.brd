File: eagle/tracker/tracker-25mm-full.brd (EAGLE design)
At the start: 70 x 26 mm, 67 parts, among them J1 BATT, J2 SHDN, J3 BATT_PYRO, J5 SAFE/ARM, M1 UBLOX-NEO-M8, M2 HOPE-RFM98W, M3 SIM800L-MODULE, U1 MS5637-02, U3 A25L010A, U4 MAG3110FCR1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

Commit message: Added pyro sensing and uBlox MAX support
Parts:
- removed D2: (no value), diode:SOT23
- removed J2: SHDN, kg-amp-ct:JST-2-PTH-VERT
- removed J5: SAFE/ARM, kg-amp-ct:JST-2-PTH-VERT
- removed M3: SIM800L-MODULE, kg-modules:SIM800L
- added J6: (no value), kg-amp-ct:JST-3-PTH-VERT
- added L1: (no value), kg-generic:R0603
- added M4: UBLOX-MAX-M8, kg-modules:UBLOX-MAX
- added Q4: (no value), kg-generic:SOT23-3
- added R15: 3.3k, rcl:R0603
- added R17, R18: 100k, kg-generic:R0603
- added R20, R26: 1k, kg-generic:R0603
- added X4: MICROMATCH-8, con-amp-micromatch:MICROMATCH-8
- X1: value MICROMATCH-4 -> 87758-0416; device con-amp-micromatch:MICROMATCH-4 -> con-molex:87758-0416
- moved R12 136.8 mm to (69.0, 31.0)
- moved C11 132.7 mm to (65.5, 33.0)
- moved U6 125.7 mm to (59.5, 33.0)
- moved R5 122.4 mm to (10.5, 15.5), turned to 180 degrees
- moved C12 117.6 mm to (52.0, 33.5)
- moved X1 53.7 mm to (-1.00, -32.0), turned to 0 degrees
- moved R10 35.6 mm to (27.5, 24.5), flipped to the top, turned to 270 degrees
- moved C4 32.6 mm to (26.5, 24.5), flipped to the bottom, turned to 270 degrees
- moved C3 32.4 mm to (44.0, 19.5), turned to 90 degrees
- moved U2 31.0 mm to (30.0, 24.5), flipped to the bottom, turned to 90 degrees
- moved C8 30.8 mm to (32.0, 24.5), turned to 90 degrees
- moved C13 30.0 mm to (44.0, 9.50), turned to 270 degrees
- moved C15 29.6 mm to (44.0, 14.0)
- moved R4 28.2 mm to (41.0, 20.5), turned to 180 degrees
- moved J4 28.0 mm to (30.0, 3.00)
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Connections:
- removed net !GSM_EN: M3.11
- removed net !GSM_RST: M3.3
- removed net GSM_RXD: M3.5
- removed net GSM_TXD: M3.4
- removed net N$26: C12.+, J3.2, JP1.2, R12.2, R16.1, X1.1, X1.3
- removed net N$27: Q3.3, R22.1, X1.2
- removed net N$28: Q2.3, R21.1, X1.4
- removed net N$30: D2.3, J5.2, R5.2
- new net DBG_RX: J6.2, U$29.13
- new net DBG_TX: J6.3, U$29.12
- new net N$24: M4.9, R15.1
- new net N$29: Q4.1, R20.2, R26.1
- new net PYRO1_OUT: Q2.3, R21.1, X4.2
- new net PYRO2_OUT: Q3.3, R22.1, X4.4
- new net SAFE: R20.1, R5.2, X4.6
- new net SENSE_ARM: R26.2, U$29.17
- new net SHDN: R10.1, U2.3, X4.8
- new net VCC_PYRO: C12.+, J3.2, JP1.2, R12.2, R16.1, X4.1, X4.3
- net !RFM_RST: no longer U$29.25
- net !RFM_SS: no longer U$29.46
- net 3.3V: now also R5.1
- net CMD1: now also R17.1, U$29.18
- net CMD2: now also R18.1, U$29.19
- net GND: now also J6.1, L1.1, M4.1, M4.10, M4.12, M4.6, Q4.2, R17.2, R18.2, X4.5, X4.7; no longer J2.1, J5.1, M3.6, Q2.2, Q3.2, R5.1
- net GPS_PPS: now also M4.4; no longer U$29.45
- net GPS_RXD: now also M4.2
- net GPS_TXD: now also M4.3
- net GPS_VCC: now also M4.7, M4.8, R15.2
- net LED: no longer U$29.38
- net N$17: now also Q2.2, Q3.2, Q4.3; no longer J2.2, R10.1, U2.3
- net N$20: no longer D2.1
- net N$25: no longer D2.2
- net N$5: now also L1.2
- net N$8: now also M4.11
- net SENSE1: now also U$29.15; no longer U$29.13
- net SENSE2: now also U$29.14; no longer U$29.12
- net V_BATT: no longer M3.2
Routing:
- net 3.3V: track 32.6 -> 81.4 mm, vias 1 -> 7
- net VCC_PYRO: track 0.00 -> 21.8 mm
- net GPS_VCC: track 14.8 -> 33.3 mm, vias 1 -> 3
- net N$13: track 18.2 -> 0.00 mm, vias 1 -> 0
- net GND: track 0.00 -> 18.2 mm, vias 36 -> 27
- net N$26: track 12.9 -> 0.00 mm
- net CMD1: track 0.00 -> 11.9 mm, vias 0 -> 1
- net SENSE1: track 15.7 -> 4.60 mm
- net PYRO2_OUT: track 0.00 -> 10.5 mm
- net PYRO_SENSE: track 13.7 -> 3.53 mm
- net PYRO1_OUT: track 0.00 -> 8.52 mm
- net SAFE: track 0.00 -> 7.87 mm, vias 0 -> 1
- net SENSE2: track 15.2 -> 7.86 mm, vias 0 -> 1
- net MOSI: track 11.1 -> 18.1 mm, vias 2 -> 3
- net BUZZER: track 26.8 -> 20.8 mm
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Other:
- board size 70 x 26 mm -> 74 x 28 mm

Commit message: Updates
Parts:
- removed X3: (no value), kg-conn-rf:SMA_EDGELAUNCH
- added X6: COAX, kg-conn-rf:MMCX-J-P-X-ST-EM1-MKT
- R20: value 1k -> 10k
- R5: value 100k -> 10k
- X2: value (none) -> COAX; device kg-conn-rf:SMA_EDGELAUNCH -> kg-conn-rf:MMCX-J-P-X-ST-EM1-MKT
- moved X1 76.8 mm to (37.5, 34.5)
- moved X2 74.7 mm to (74.0, 20.0), turned to 90 degrees
- moved C6 19.5 mm to (32.0, 19.0), turned to 270 degrees
- moved FB1 16.1 mm to (30.0, 19.0), turned to 90 degrees
- moved L1 5.30 mm to (65.0, 20.8), turned to 270 degrees
- moved R5 4.03 mm to (12.5, 12.0), flipped to the bottom, turned to 0 degrees
- moved R26 2.92 mm to (11.5, 14.5), flipped to the top, turned to 90 degrees
- moved R20 1.12 mm to (9.50, 14.5), turned to 90 degrees
- moved C7 1.00 mm to (41.0, 6.00)
- moved R14 1.00 mm to (41.0, 4.50)
- moved U3 1.00 mm to (41.0, 6.50)
- moved C10 0.50 mm to (26.0, 20.0)
- moved R11 0.50 mm to (23.0, 20.0)
- moved R13 0.50 mm to (24.5, 20.0)
- moved R8 0.50 mm to (58.5, 15.0)
Connections:
- net CMD1: now also U$29.19; no longer U$29.18
- net CMD2: now also U$29.18; no longer U$29.19
- net GND: now also X2.2@1, X2.2@2, X2.2@3, X2.2@4, X6.2@1, X6.2@2, X6.2@3, X6.2@4; no longer X2.GND@1, X2.GND@2, X2.GND@3, X2.GND@4, X3.GND@1, X3.GND@2, X3.GND@3, X3.GND@4
- net N$29: now also R20.1, R5.2; no longer R20.2
- net N$31: now also X6.1; no longer X2.P
- net N$5: now also X2.1; no longer X3.P
- net RFM_DIO0: now also U$29.20
- net SAFE: now also R20.2; no longer R20.1, R5.2
- net SCL: now also U$29.45; no longer U$29.21
- net SDA: now also U$29.46; no longer U$29.22
Routing:
- net !RST: track 1.50 -> 17.3 mm, vias 0 -> 2
- net DBG_TX: track 0.00 -> 14.7 mm, vias 0 -> 1
- net DBG_RX: track 0.00 -> 14.0 mm, vias 0 -> 1
- net N$13: track 0.00 -> 11.7 mm
- net BUZZER: track 20.8 -> 32.3 mm
- net SENSE_ARM: track 0.00 -> 11.2 mm
- net SCL: track 11.8 -> 22.2 mm
- net SWDIO: track 0.00 -> 10.1 mm, vias 0 -> 1
- net SDA: track 15.7 -> 25.6 mm
- net RFM_DIO0: track 0.00 -> 8.97 mm, vias 0 -> 1
- net N$31: track 17.2 -> 8.70 mm
- net SWCLK: track 0.00 -> 8.02 mm
- net SENSE2: track 7.86 -> 14.7 mm
- net !FLASH_CS: track 1.98 -> 8.10 mm, vias 1 -> 2
- net SENSE1: track 4.60 -> 10.4 mm
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Other:
- board text added: "TODO: - TABS for battery straps"

Commit message: Updates
Parts:
- removed X5: B3710U410, kg-radio:DCC6C
- C12: device rcl:E5-8,5 -> rcl:E3,5-8
- moved R12 46.9 mm to (22.5, 25.0), turned to 270 degrees
- moved C11 41.8 mm to (24.5, 25.0), turned to 90 degrees
- moved U6 36.9 mm to (23.5, 25.0), flipped to the bottom, turned to 270 degrees
- moved C12 35.9 mm to (17.0, 25.5)
- moved R16 20.2 mm to (25.5, 20.0), turned to 270 degrees
- moved R23 18.4 mm to (24.0, 20.0), turned to 270 degrees
- moved R9 17.0 mm to (33.0, 20.0), turned to 90 degrees
- moved C1 14.9 mm to (31.5, 20.0), turned to 270 degrees
- moved M2 12.6 mm to (37.0, 19.5)
- moved JP1 9.50 mm to (26.0, 22.5)
- moved JP5 9.00 mm to (43.0, 22.5)
- moved C2 7.00 mm to (43.0, 24.0)
- moved C4 7.00 mm to (33.5, 24.5)
- moved C5 7.00 mm to (40.5, 24.5)
- moved C8 7.00 mm to (39.0, 24.5)
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Connections:
- removed net N$8: M1.11, M4.11, X5.5
- net !FLASH_CS: now also U$29.38
- net !RFM_RST: now also U$29.32
- net !RFM_SS: now also U$29.33
- net !RST: now also J4.4; no longer J4.2
- net BUZZER: now also U$29.30
- net GND: no longer X5.1, X5.3, X5.4, X5.6
- net GPS_PPS: now also U$29.31
- net N$5: now also M1.11, M4.11; no longer X5.2
- net PYRO1_OUT: now also X4.4; no longer X4.2
- net PYRO2_OUT: now also X4.2; no longer X4.4
- net SWDIO: now also J4.2; no longer J4.4
Routing:
- net 3.3V: track 76.7 -> 106.8 mm, vias 8 -> 10
- net GPS_PPS: track 30.4 -> 50.0 mm, vias 3 -> 2
- net BUZZER: track 32.3 -> 45.6 mm
- net !RFM_SS: track 0.00 -> 11.7 mm, vias 0 -> 1
- net !FLASH_CS: track 8.10 -> 19.7 mm, vias 2 -> 1
- net !RFM_RST: track 0.00 -> 11.2 mm, vias 0 -> 1
- net VCC_PYRO: track 21.8 -> 31.1 mm
- net !RST: track 17.3 -> 24.5 mm, vias 2 -> 1
- net N$31: track 8.70 -> 15.8 mm
- net N$13: track 11.7 -> 18.5 mm, vias 0 -> 1
- net V_BATT: track 70.2 -> 64.4 mm
- net SENSE_ARM: track 11.2 -> 15.7 mm
- net SENSE2: track 14.7 -> 19.2 mm
- net SENSE1: track 10.4 -> 14.9 mm
- net CMD2: track 8.45 -> 12.9 mm
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
Commit message: Updates to tracker
Parts:
- added J2: (no value), kg-amp-ct:JST-8-PTH-VERT
- added TP1: TPB1,27, testpad:B1,27
- added U7: H3LIS100DL, kg-ic:QFN16_3X5
- moved D1 32.7 mm to (22.5, 7.00), flipped to the top, turned to 90 degrees
- moved R6 32.2 mm to (24.0, 7.00), turned to 90 degrees
- moved X1 10.6 mm to (48.0, 33.0)
- moved JP1 1.58 mm to (27.5, 23.0)
- moved C8 1.41 mm to (40.0, 25.5), turned to 180 degrees
- moved JP5 1.12 mm to (42.0, 23.0), turned to 270 degrees
- moved R8 1.12 mm to (61.0, 17.0)
- moved C2 1.00 mm to (42.0, 24.0)
- moved C5 1.00 mm to (39.5, 24.5)
- moved X4 1.00 mm to (3.50, 19.5)
- moved C1 0.50 mm to (31.0, 20.0)
- moved C10 0.50 mm to (29.5, 20.0)
- moved C11 0.50 mm to (24.5, 24.5)
- moved C14 0.50 mm to (42.5, 9.50)
- moved C6 0.50 mm to (37.0, 20.0)
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Connections:
- net !RST: now also TP1.TP; no longer J4.4
- net 3.3V: now also U7.P1, U7.P14, U7.P7, U7.P8
- net GND: now also U7.P10, U7.P12, U7.P13, U7.P15, U7.P16, U7.P5
- net SCL: now also U7.P4
- net SDA: now also U7.P6
Routing:
- net SHDN: track 1.23 -> 41.9 mm, vias 1 -> 2
- net !RST: track 24.5 -> 6.47 mm, vias 1 -> 0
- net SDA: track 24.9 -> 15.8 mm
- net SCL: track 21.6 -> 13.0 mm
- net VCC_PYRO: track 31.1 -> 33.6 mm
- net V_BATT: track 64.4 -> 62.5 mm
- net 3.3V: track 106.8 -> 108.0 mm, vias 10 -> 8
- net N$19: track 0.58 -> 0.00 mm, vias 1 -> 0
- net !RFM_RST: track 11.2 -> 11.8 mm
- net SCK: track 16.8 -> 17.3 mm
- net N$22: track 2.30 -> 1.80 mm
- net MOSI: track 18.5 -> 19.0 mm
- net MISO: track 27.5 -> 28.0 mm
- net GPS_VCC: track 33.0 -> 32.5 mm
- net !RFM_SS: track 11.7 -> 12.2 mm
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Other:
- board text added: "TODO: - TABS for battery straps - Check buzzer size - Wire widths"
- board text removed: "TODO: - TABS for battery straps"

Commit message: Tracker ready for order
Parts:
- removed C12: (no value), rcl:E3,5-8
- removed J2: (no value), kg-amp-ct:JST-8-PTH-VERT
- removed X1: 87758-0416, con-molex:87758-0416
- added C16: 1u, kg-generic:C603
- added C17: 100n, kg-generic:C603
- added TP2, TP3, TP4, TP5: TPB1,27, testpad:B1,27
- moved D1 9.01 mm to (15.0, 2.00), turned to 180 degrees
- moved R6 7.43 mm to (18.5, 2.00), turned to 0 degrees
- moved FB3 2.69 mm to (51.0, 20.5)
- moved C11 2.61 mm to (22.0, 25.2), flipped to the bottom, turned to 180 degrees
- moved C6 2.50 mm to (37.0, 17.5)
- moved FB1 2.50 mm to (35.0, 17.5)
- moved R15 1.50 mm to (56.0, 20.0)
- moved R16 1.50 mm to (23.5, 20.0)
- moved R23 1.50 mm to (25.0, 20.0)
- moved R12 1.12 mm to (22.0, 23.5), flipped to the bottom, turned to 0 degrees
- moved R10 1.00 mm to (35.5, 24.5)
- moved U7 1.00 mm to (40.5, 19.0)
- moved J3 0.75 mm to (17.0, 24.9)
- moved JP1 0.71 mm to (27.0, 22.5)
- moved C5 0.50 mm to (40.0, 24.5)
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Connections:
- net N$24 renamed !GPS_RST
- removed net VCC_PYRO: C12.+, J3.2, JP1.2, R12.2, R16.1, X4.1, X4.3
- new net V_PYRO: J3.2, JP1.2, R12.2, R16.1, X4.1, X4.3
- net !RST: now also J4.4
- net 3.3V: now also C16.2, C17.2
- net GND: now also C16.1, C17.1, TP3.TP, TP4.TP, TP5.TP; no longer C12.-
- net GPS_PPS: now also TP2.TP
- net LED: now also U$29.25
Routing:
- net V_PYRO: track 0.00 -> 36.8 mm, vias 0 -> 1
- net VCC_PYRO: track 33.6 -> 0.00 mm
- net 3.3V: track 108.0 -> 139.8 mm, vias 8 -> 12
- net !RST: track 6.47 -> 24.0 mm, vias 0 -> 1
- net SDA: track 15.8 -> 28.2 mm, vias 3 -> 4
- net SCL: track 13.0 -> 22.3 mm, vias 2 -> 3
- net LED: track 0.00 -> 9.07 mm
- net GND: track 19.7 -> 24.3 mm, vias 36 -> 80
- net N$5: track 1.33 -> 4.95 mm, vias 1 -> 2
- net N$21: track 0.00 -> 2.63 mm, vias 0 -> 1
- net GPS_VCC: track 32.5 -> 30.1 mm, vias 4 -> 3
- net V_BATT: track 62.5 -> 60.2 mm, vias 2 -> 4
- net N$13: track 18.7 -> 16.8 mm
- net N$19: track 0.00 -> 1.70 mm
- net GPS_PPS: track 50.0 -> 51.1 mm
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Other:
- board text added: "(c) Karlis Goba 2018"
- board text added: "LoRa-TINY"
- board text removed: "EXT"
- board text removed: "SDN"

Commit message: Updates
Connections:
- net CMD1 renamed D_PYRO2
- net CMD2 renamed D_PYRO1
- net PYRO_SENSE renamed SENSE_VPYRO
- net SENSE1 renamed SENSE_P2
- net SENSE2 renamed SENSE_P1
- net V_BATT_SENSE renamed SENSE_VBATT
- net RFM_DIO0: now also U$29.21; no longer U$29.20
Changed lines of the file:
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@@
 <signal name="RFM_DIO0">
 <contactref element="M2" pad="14"/>
-<contactref element="U$29" pad="20"/>
 <wire x1="21.38" y1="16" x2="20.5" y2="16" width="0.254" layer="16"/>
 <wire x1="20.5" y1="16" x2="19.75" y2="15.25" width="0.254" layer="16"/>
 <wire x1="19.75" y1="15.25" x2="19.75" y2="12" width="0.254" layer="16"/>
 <via x="19.75" y="12" extent="1-16" drill="0.4" shape="octagon"/>
-<wire x1="24.25" y1="11.25" x2="20.5" y2="11.25" width="0.254" layer="1"/>
 <wire x1="20.5" y1="11.25" x2="19.75" y2="12" width="0.254" layer="1"/>
+<contactref element="U$29" pad="21"/>
+<wire x1="20.5" y1="11.25" x2="22.75" y2="11.25" width="0.254" layer="1"/>
+<wire x1="22.75" y1="11.25" x2="23.25" y2="10.75" width="0.254" layer="1"/>
+<wire x1="23.25" y1="10.75" x2="24.25" y2="10.75" width="0.254" layer="1"/>
 </signal>
 <signal name="!RFM_RST">
@@
 <via x="61" y="17.75" extent="1-16" drill="0.4" shape="octagon"/>
 </signal>
-<signal name="V_BATT_SENSE">
+<signal name="SENSE_VBATT">
 <contactref element="R11" pad="1"/>
 <contactref element="R13" pad="2"/>
@@
 <wire x1="17.65" y1="2" x2="15.95" y2="2" width="0.254" layer="1"/>
 </signal>
-<signal name="PYRO_SENSE">
+<signal name="SENSE_VPYRO">
 <contactref element="R16" pad="2"/>
 <contactref element="R23" pad="2"/>
@@
 <wire x1="4.905" y1="20" x2="4.77" y2="20.135" width="0.6096" layer="1"/>
 </signal>
-<signal name="SENSE1">
+<signal name="SENSE_P2">
 <contactref element="R21" pad="2"/>
 <contactref element="R24" pad="2"/>
@@
 <wire x1="23.05" y1="13.75" x2="19.15" y2="17.65" width="0.254" layer="1"/>
 </signal>
-<signal name="SENSE2">
+<signal name="SENSE_P1">
 <contactref element="R22" pad="2"/>
 <contactref element="R25" pad="2"/>
@@
 <wire x1="43.35" y1="9.5" x2="42.5" y2="10.3" width="0.2" layer="16"/>
 </signal>
-<signal name="CMD1">
+<signal name="D_PYRO2">
 <contactref element="R19" pad="1"/>
 <contactref element="R17" pad="1"/>
@@
 <wire x1="7.55" y1="15.4" x2="7.5" y2="15.35" width="0.4064" layer="1"/>
 </signal>
-<signal name="CMD2">
+<signal name="D_PYRO1">
 <contactref element="R1" pad="1"/>
 <contactref element="R18" pad="1"/>
