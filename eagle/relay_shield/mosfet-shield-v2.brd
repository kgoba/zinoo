# Repository kgoba/zinoo (continued)

## EAGLE design eagle/tracker/flight-28mm.brd

Parts:
C1, C3, C7, C10, C13, C14, C15, C17: 100n; C603
C2: 10u; EIA3216
C4, C5, C8, C11, C16: 1u; C603
C6, C9: CAPACITOR_NPOL-0603; C603
C12: 3.0F; E3,5-8
D1: LED0805; R0805
J1: BATT; JST-2-PTH-VERT
J2: USB_MINI-B_SMT; USB-MINIB
J4: M4-CT-V; JST-4-PTH-VERT
J6: M3-CT-V; JST-3-PTH-VERT
JP1: BYPASS2; PAD-JUMPER-2-NO_YES_SILK
JP2: CFG1; PAD-JUMPER-2-NO_YES_SILK
JP3: CFG2; PAD-JUMPER-2-NO_YES_SILK
JP5: LDO_BYPASS; PAD-JUMPER-2-NO_YES_SILK
PAD1, PAD2: SMD5; SMD2,54-5,08
Q1, Q2, Q3, Q4: MOSFET-N-SOT23-3; SOT23-3
R1, R6, R7, R19, R26: 1k; R0603
R2, R5, R14, R20: 10k; R0603
R3, R4: 4k7; R0603
R9: RESISTOR-0603; R0603
R10, R11, R13, R16, R17, R18, R21, R22, R23, R24, R25: 100k; R0603
R12: 100; R0603
SG1: F/TMB
TP1, TP3: TPB1,27; B1,27
U1: LIS3MDL; VFLGA-12
U2: VREG-5PIN-SOT23; SOT23-5
U3: A25L010A; SOP08
U4: MAG3110FCR1; DFN200X200X90-10N
U5: LSM6DS33; TFLGA16L
U6: LP3985IM5-2.7; SOT23-5
U7: H3LIS100DL; QFN16_3X5
U8: MMA6825; QFN16_6X6
U10: MPL3115A2; LGA8
U$29: STM32L063C; LQFP48
X4: MICROMATCH-8

Connections:
3.3V: C2.A (+), C3.2, C5.2, C7.2, C15.2, C16.2, C17.2, JP2.2, JP3.2, JP5.2, R3.2, R4.2, R5.1, R9.2, R14.2, U1.5 (VDD), U1.6 (VDD_IO), U1.9 (SD0/SA1), U1.10 (CS), U2.5 (OUT), U3.3 (WP), U3.7 (HOLD), U3.8 (VCC), U4.2 (VDD), U4.8 (VDDIO), U5.1 (VDD_IO), U5.4 (SDO), U5.5 (CS), U5.16 (VDD), U6.1 (IN), U6.3 (EN), U7.P1 (VDD_IO), U7.P7 (SDO/SA0), U7.P8 (CS), U7.P14 (VDD), U10.1 (VDD), U10.4 (VDDIO), U$29.1 (VBAT), U$29.9 (VDDA), U$29.24 (VDD1), U$29.36 (VDDIO2/PF7), U$29.48 (VDD2)
!FLASH_CS: R14.1, U3.1 (CS), U$29.38 (PA15)
!RST: C1.2, J4.4, R9.1, TP1.TP, U$29.7 (NRST)
BUZZER: R7.1, U$29.30 (PA9)
DBG_RX: J6.2, U$29.13 (PA3)
DBG_TX: J6.3, U$29.12 (PA2)
D_PYRO1: R1.1, R18.1, U$29.18 (PB0)
D_PYRO2: R17.1, R19.1, U$29.19 (PB1)
GND: C1.1, C2.C (-), C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.-, C13.1, C14.1, C15.1, C16.1, C17.1, D1.2 (C), J1.1, J2.GND, J4.1, J6.1, Q1.2 (S), Q4.2 (S), R2.1, R13.1, R17.2, R18.2, R23.1, R24.1, R25.1, TP3.TP, U1.2 (RES1), U1.3 (GND), U1.12 (RES2), U2.2 (GND), U3.4 (GND), U4.5 (GND_2), U4.10 (GND), U5.8 (RES1), U5.9 (RES2), U5.10 (RES3), U5.11 (RES4), U5.12 (GND1), U5.13 (GND2), U5.15 (RES5), U6.2 (GND), U7.P5 (GND1), U7.P10 (RES1), U7.P12 (GND2), U7.P13 (GND3), U7.P15 (RES2), U7.P16 (GND4), U10.3 (GND), U$29.8 (VSSA), U$29.23 (VSS1), U$29.35 (VSS/PF6), U$29.44 (BOOT0), U$29.47 (VSS2), X4.5, X4.7
GPS_RXD: U$29.43 (PB7)
GPS_TXD: U$29.42 (PB6)
LED: R6.2, U$29.25 (PB12)
MISO: U3.2 (SO), U$29.40 (PB4)
MOSI: U3.5 (SI), U$29.41 (PB5)
unnamed: C9.2, U1.4 (C1)
unnamed: Q1.1 (G), R2.2, R7.2
unnamed: PAD2.1, Q1.3 (D), SG1.-
unnamed: C8.2, U2.4 (BP)
unnamed: Q2.2 (S), Q3.2 (S), Q4.3 (D)
unnamed: D1.1 (A), R6.1
unnamed: Q2.1 (G), R19.2
unnamed: C11.2, R12.1, U6.5 (OUT)
unnamed: C13.2, U4.1 (CAP-A)
unnamed: C14.2, U4.4 (CAP-R)
unnamed: C6.2, JP2.1, U10.2 (CAP)
unnamed: Q3.1 (G), R1.2
unnamed: JP3.1, U10.5 (INT2)
unnamed: Q4.1 (G), R5.2, R20.1, R26.1
PYRO1_OUT: Q2.3 (D), R21.1, X4.4
PYRO2_OUT: Q3.3 (D), R22.1, X4.2
SAFE: R20.2, X4.6
SCK: U3.6 (SCK), U$29.39 (PB3)
SCL: R3.1, U1.1 (SCL/SPC), U4.7 (SCL), U5.2 (SCL), U7.P4 (SCK/SCL), U10.8 (SCL), U$29.45 (PB8)
SDA: R4.1, U1.11 (SDA/SDI), U4.6 (SDA), U5.3 (SDA), U7.P6 (SDI/SDA), U10.7 (SDA), U$29.46 (PB9)
SENSE_ARM: R26.2, U$29.17 (PA7)
SENSE_P1: R22.2, R25.2, U$29.14 (PA4)
SENSE_P2: R21.2, R24.2, U$29.15 (PA5)
SENSE_VBATT: C10.2, R11.1, R13.2, U$29.10 (PA0)
SENSE_VPYRO: R16.2, R23.2, U$29.11 (PA1)
SHDN: R10.1, U2.3 (EN), X4.8
SWCLK: J4.3, U$29.37 (SWCLK/PA14)
SWDIO: J4.2, U$29.34 (SWDIO/PA13)
VBUS: J2.VBUS
VCC: U8.9 (VCC)
VPP: U8.7 (VPP)
VSS: U8.2 (VSS), U8.4 (VSS), U8.PAD (VSS)
VSSA: U8.13 (VSSA), U8.16 (VSSA)
V_BATT: C4.2, J1.2, JP1.1, JP5.1, PAD1.1, R10.2, R11.2, SG1.+, U2.1 (IN)
V_PYRO: C12.+, JP1.2, R12.2, R16.1, X4.1, X4.3

Notes on the sheet:
Barometer (optional)
SPI Flash (optional)
MPL3115A2 CFG1=open CFG2=open MPL1115A2 CFG1=open CFG2=short MS5607-02 CFG1=short CFG2=short

Board: 2 copper layers, 74.0 x 28.0 mm, 70 parts (26 on the bottom side), 44 nets.

## EAGLE design eagle/tracker/tracker-ground-v1_1.brd

Parts:
C1: 10n; C603
C2, C18: 1u; C603
C3, C6, C7, C9, C10, C11, C17: 100n; C603
C4, C19: 4.7u; C1206
C5: NF*; C603
C8: *100n; C603
D1: DIODE-SCHOTTKY-SOD323; SOD-323
D2: DIODE-2AC|CASOT23; SOT23
ESD1: NF; _0603MP
ESD2: 0.25p; _0603MP
FB2, FB4, FB5: FERRITE_0805; _0805
JP1: BATT; 1X02
JP2, JP3: I2C; 1X04
JP4, JP5: PINHD-1X2; 1X02
JP6: PROG; 1X04
L1: L-0805; R0805
LED1, LED2, LED4: LEDCHIPLED_0805; CHIPLED_0805
M1: UBLOX-NEO-6; UBLOX-NEO
M2: HOPE-RFM98W; HOPE-RFM
M3: TFT-2.0-OPENSMART-THT; TFT-2.0-OPENSMART
M5: SIM800L-MODULE; SIM800L-BOARD
Q1: Si2365; SOT23-3
Q2: CPH3448; SOT23-3
R1, R9: 1k; R0603
R2, R3: 4.7k; R0603
R4, R15: 10k; R0603
R5, R6, R11: 22; R0603
R7, R8, R16, R17, R18, R19, R20: 2.2k; R0603
R10, R12, R13, R14: 100k; R0603
S1, S2, S3, S4: MOMENTARY-SWITCH-SPST-SMD-6.2MM-TALL; TACTILE_SWITCH_SMD_6.2MM_TALL
TP1, TP3: TPSB1,27; B1,27
U1: RT9013-33; SOT23-5
U2: MCP73831; SOT23-5
U3: A25L010A; SOP08
U4: VREG-3PIN-DPAK; DPAK
U8: STM32L063C; LQFP48
U$42: USBMINIB; USB-MINIB
X1, X2, X3: SMACONNECTOR_EDGE; SMA_EDGELAUNCH
X4: ANTENNA-PATCH-12X12; ANT-PATCH-12X12

Connections:
!FLASH_CS: R15.1, U3.1 (CS), U8.29 (PA8)
!LORA_CS: M2.5 (!SS), U8.18 (PB0)
!LORA_IRQ: M2.14 (DIO0), U8.20 (PB2)
!LORA_RST: M2.6 (!RESET), U8.19 (PB1)
!RST: C1.2, JP6.4, R4.1, U8.7 (NRST)
!TFT_CS: M3.P$6 (!CS), U8.21 (PB10)
!TFT_LED: M3.P$8 (LED), U8.16 (PA6)
!TFT_RST: M3.P$7 (!RST), U8.17 (PA7)
+3V3: C2.2, C3.2, C7.2, FB2.1, FB4.2, JP2.4, JP3.4, M3.P$2 (VCC), R2.2, R3.2, R4.2, R15.2, U1.5 (OUT), U3.3 (WP), U3.7 (HOLD), U3.8 (VCC), U8.9 (VDDA), U8.24 (VDD1), U8.36 (VDDIO2/PF7), U8.48 (VDD2)
BAT_CHG: D1.A, U8.39 (PB3)
BTN1: D2.1 (A1), U8.40 (PB4)
BTN2: S2.A2 (1), U8.41 (PB5)
BTN3: S3.A2 (1), U8.42 (PB6)
BTN4: S4.A2 (1), U8.43 (PB7)
BTN_ON: D2.2 (A2), Q1.1 (G), Q2.3 (D), R12.1
DBG_RXD: JP3.3
DBG_TXD: JP3.2
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.1, C8.2, C9.1, C10.1, C11.1, C17.1, C18.1, C19.1, ESD1.1, ESD2.1, JP1.1, JP2.1, JP3.1, JP6.1, M1.7 (VDDUSB), M1.10 (GND), M1.12 (GND), M1.13 (GND), M1.22 (V_BCKP), M1.24 (GND), M2.1 (GND1), M2.8 (GND2), M2.10 (GND3), M3.P$1 (GND), M5.6 (GND), Q2.2 (S), R1.1, R7.1, R9.1, R10.1, R14.1, R19.2, R20.2, S1.B2 (2), S2.B2 (2), S3.B2 (2), S4.B2 (2), TP1.TP, U1.2 (GND), U2.2 (VSS), U3.4 (GND), U8.8 (VSSA), U8.23 (VSS1), U8.35 (VSS/PF6), U8.44 (BOOT0), U8.47 (VSS2), U$42.GND, X2.GND@1 (GND4), X2.GND@2 (GND3), X2.GND@3 (GND2), X2.GND@4 (GND1), X3.GND@1 (GND4), X3.GND@2 (GND3), X3.GND@3 (GND2), X3.GND@4 (GND1)
GND1: X1.GND@4 (GND1)
GND2: X1.GND@3 (GND2)
GND3: X1.GND@2 (GND3)
GND4: X1.GND@1 (GND4)
GPS_PPS: LED2.A, M1.3 (TIMEPULSE), U8.14 (PA4)
GPS_RXD: M1.20 (TXD1), TP3.TP, U8.13 (PA3)
GPS_TXD: M1.21 (RXD1), U8.12 (PA2)
GSM_DTR: R16.2, U8.25 (PB12)
GSM_RXD: R18.2, U8.31 (PA10)
GSM_TXD: R17.2, U8.30 (PA9)
LED: LED4.A, U8.38 (PA15)
MISO: M2.2 (MISO), U3.2 (SO), U8.27 (PB14)
MOSI: M2.3 (MOSI), M3.P$3 (SDI), U3.5 (SI), U8.28 (PB15)
unnamed: LED4.C, R9.2
unnamed: M1.8 (RES1), M1.9 (VCC_RF), R11.2
unnamed: C8.1, U1.4 (BP)
unnamed: LED2.C, R1.2
unnamed: L1.2, R11.1
unnamed: R7.2, U2.5 (PRG)
unnamed: C5.1, ESD1.2, L1.1, X3.P (ANT)
unnamed: LED1.C, R8.2
unnamed: C18.2, JP4.2, Q1.3 (D), R13.2, U1.1 (IN), U1.3 (EN)
unnamed: C5.2, M1.11 (RF_IN), X4.FEED
unnamed: D2.3 (C), S1.A2 (1)
unnamed: D1.C, R8.1, U2.1 (STAT)
unnamed: C11.2, U8.1 (VLCD/VBAT)
unnamed: M5.1 (ANT), X1.P (ANT)
unnamed: M5.11 (DTR), R16.1, R19.1
unnamed: M5.5 (TXD), R18.1
unnamed: C6.2, FB5.2, U$42.VBUS
unnamed: M5.4 (RXD), R17.1, R20.1
unnamed: C10.2, FB4.1, M2.13 (3.3V)
unnamed: R5.1, U$42.D-
unnamed: ESD2.2, M2.9 (ANT), X2.P (ANT)
unnamed: R6.1, U$42.D+
unnamed: C9.2, FB2.2, M1.2 (SS_N), M1.23 (VCC)
PWR_ON: Q2.1 (G), R14.2, U8.2 (PC13)
SCK: M2.4 (SCK), M3.P$4 (SCK), U3.6 (SCK), U8.26 (PB13)
SCL: JP2.2, R2.1, U8.45 (PB8)
SDA: JP2.3, R3.1, U8.46 (PB9)
SWCLK: JP6.3, U8.37 (PA14)
SWDIO: JP6.2, U8.34 (PA13)
TFT_RS: M3.P$5 (D/C), U8.22 (PB11)
USB_DM: R5.2, U8.32 (PA11)
USB_DP: R6.2, U8.33 (PA12)
USB_VBUS: C19.2, FB5.1, LED1.A, U2.4 (VDD)
VBAT_ADC: C17.2, R10.2, R13.1, U8.10 (PA0)
V_BATT: C4.2, JP1.2, JP4.1, M5.2 (VCC), Q1.2 (S), R12.2, U2.3 (BAT)

Board: 2 copper layers, 110.0 x 65.0 mm, 73 parts (22 on the bottom side), 60 nets.
