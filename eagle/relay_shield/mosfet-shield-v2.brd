# Repository kgoba/zinoo

File README.md:

# About

Collection of High Altitude Balloon projects for Zinoo science center:

 * `zinoo-liepaja`: Custom built ATMega328p based payload tracker firmware.
 * `zinoo-lora`: LoRa-based payload tracker firmware. It uses Arduino Uno + Dragino LoRa/GPS shield.
 * `zinoo-lora-ground`: LoRa-based ground station firmware. It uses Arduino Uno + Dragino LoRa/GPS shield.

# Getting Started

If you cloned this repository, please make sure to update all the dependencies by executing

```bash
git submodule init
git submodule update
```

Please install PlatformIO to build the firmware (see [Installation guide](http://docs.platformio.org/en/latest/installation.html)), e.g. by executing

```bash
sudo -H pip install -U platformio
```

To use the telemetry upload script, the `pyserial` library is required. You can install it by executing

```bash
sudo -H pip install -U pyserial
```

Note that you might want to skip the `sudo -H` in front of these commands, depending on your setup.

```bash
sudo pip install -r requirements.txt
```

# Building and uploading

To build `zinoo-lora` and `zinoo-lora-ground`, change directory to the corresponding project and execute

```bash
pio run
```

The `zinoo-lora` project builds several variants of the firmware (see the project definition file `zinoo-lora/platformio.ini`). To upload the code to an Arduino board, connect it and execute 

```bash
pio run -t upload -e <variant>
```

Where `<variant>` is currently one of `uno_z71`, `uno_z72`, `uno_z73` or `uno_z74`. Variants are defined in the project definition file.

To upload the `zinoo-lora-ground` project, you can simply execute

```bash
pio run -t upload
```

# Upload to *habhub*

The script `habhub-upload.py` can be used to monitor, log, and upload received telemetry to the habhub platform. To do that, you need to specify the receiver callsign and the serial port device of the connected Arduino board, e.g.

```bash
python habhub-upload.py GROUND-1 /dev/ttyUSB0
```

The script will echo all strings received from the serial port, as well as automatically attempt to upload strings beginning with `$$`. All displayed information is also logged into a timestamped logfile, which is created in the current working directory.

## EAGLE design eagle/relay_shield/mosfet-shield-v2.brd

Parts:
C1, C2, C3, C4, C6: 2.2u; C1206
C5, C7: CAPACITOR_NPOL-0603; C603
D1, D8, D9, D10: DIODE-ZENER-SOD80; SOD80
D2, D3, D4, D5, D6, D7: BAT54C; SOT23
IC1: ULN2003AD; SO16
J2: Y1B; SCREWTERMINAL-3.5MM-2
J3: Y1A; SCREWTERMINAL-3.5MM-2
J4: Y2A; SCREWTERMINAL-3.5MM-2
J5: X2; SCREWTERMINAL-3.5MM-2
J6: Y2B; SCREWTERMINAL-3.5MM-2
J7: X1; SCREWTERMINAL-3.5MM-2
J8: M023.5MM; SCREWTERMINAL-3.5MM-2
JP1, JP2, JP3, JP4: JP2E; JP2
JP5: SYNC_OUT; 1X02
JP6: PINHD-1X3; 1X03
Q1, Q2, Q3, Q4, Q5: PMV33; SOT23-3
Q6: BJT-NPN-SOT23-3; SOT23-3
R1, R2, R3, R4, R5, R7, R8, R9, R10: 1k; R0603
R6: 22; R0603
SC1: 3.0F; E3,5-8
U1: NCP5501DT50G; DPAK
U2: VREG-5PIN-SOT23; SOT23-5
U3: MCP23008-E/SO; SOIC127P1030X265-18N

Connections:
5V: C2.2, C4.2, D6.1 (A1), D6.2 (A2), D7.3 (C), JP6.1, R1.2, U1.3 (OUT), U2.1 (IN), U2.3 (EN)
BUZZER_ON: R10.1
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.2, IC1.8 (GND), IC1.9 (CD+), J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, JP1.1, JP2.1, JP3.1, JP4.1, JP5.1, Q1.1 (G), Q6.2 (E), R8.1, R9.1, SC1.-, U1.4 (ADJ/GND), U2.2 (GND)
unnamed: D2.2 (A2), JP1.2
unnamed: D3.2 (A2), JP2.2
unnamed: J3.2, Q4.3 (D)
unnamed: C3.2, C6.2, Q1.2 (S), U1.1 (IN)
unnamed: IC1.15 (O2), Q3.1 (G), R3.1
unnamed: IC1.16 (O1), Q2.1 (G), R2.1
unnamed: J7.2, Q4.2 (S), Q5.2 (S), R4.2, R5.2
unnamed: J2.2, Q5.3 (D)
unnamed: J4.2, Q2.3 (D)
unnamed: J5.2, Q2.2 (S), Q3.2 (S), R2.2, R3.2, R6.2, SC1.+
unnamed: J6.2, Q3.3 (D)
unnamed: IC1.14 (O3), Q4.1 (G), R4.1
unnamed: IC1.13 (O4), Q5.1 (G), R5.1
unnamed: C1.2, D7.1 (A1), D7.2 (A2), R6.1, U2.5 (OUT)
unnamed: C5.2, JP5.2
unnamed: D2.3 (C), IC1.1 (I1)
unnamed: D3.3 (C), IC1.2 (I2)
unnamed: D4.3 (C), IC1.3 (I3)
unnamed: D5.3 (C), IC1.4 (I4)
unnamed: C5.1, R7.1, R8.2
unnamed: D4.2 (A2), JP3.2
unnamed: D5.2 (A2), JP4.2
unnamed: JP6.2, Q6.3 (C)
unnamed: J8.2, Q1.3 (D)
unnamed: Q6.1 (B), R10.2
unnamed: JP1.3, JP2.3, JP3.3, JP4.3, R1.1
NTC_ADC: C7.1, JP6.3, R9.2
VDD: U3.18 (VDD)

Notes on the sheet:
Reverse polarity protection

Board: 2 copper layers, 80.0 x 60.0 mm, 51 parts (32 on the bottom side), 29 nets.

File eagle/relay_shield/bom.txt:

1629032	6	RY211005R	SPDT Relay 5V
1564671	1	LP2985IM5-5.0/NOPB LDO 5V/150mA
1703369	1	NCP5501DT50G 	LDO 5V/500mA
9227911	4	C1206C225K4RACTU 	2.2uF 16V
1081192	4	BAT54C		Double diode (ACA)
1332086	1	MCP23008-E/SO	I/O Expander, 8 bit
2769437	1	ULN2003ADRG3		Transistor array
2527545	1	CTBP3051/2		Terminal block 2W
2527546	6	CTBP3051/3		Terminal block 3W

## EAGLE design eagle/misc/thermostat-2layer-v1.brd

Parts:
D2: RED; R0805
D3: DIODE-SMA-ALT; D-SMA-ALT
D4: NF; SOD80
J1, J7: V_EXT; JST-2-PTH-VERT
J2: M3-CT-V; JST-3-PTH-VERT
J8: V_BATT; JST-2-PTH-VERT
J9: NTC 10k; JST-2-PTH-VERT
PAD1, PAD2: WIREPADSMD1,27-254; SMD1,27-2,54
Q2: BJT-PNPSMD; SOT23-3
Q3: BJT-NPN-SOT23-3; SOT23-3
Q4, Q5: MOSFET-P-SOT23-3; SOT23-3
R1, R3, R27: 1k; R0603
R2, R4, R6, R7, R9, R10, R12, R14, R15, R16, R17, R18, R19, R20, R21: 10; R1206
R5, R8: 10k; R0603
R11: 6.8k; R0603
R13: 100k; R0603
R22: NF; R0603
U1: TL431DBZ; SOT23-3

Connections:
!SAFE: J1.2, Q3.3 (C)
EN/VREF: J2.3, R22.1
GND: D4.C, J1.1, J2.1, J7.1, J8.1, J9.1, PAD2.1, Q3.2 (E), R1.1, R5.1, R7.1, R10.1, R14.1, R17.1, R20.1, U1.3 (A)
LOAD: Q5.3 (D), R2.2, R6.2, R12.2, R13.2, R16.2, R19.2
unnamed: D2.2 (C), R27.1
unnamed: D4.A, R3.1
unnamed: R2.1, R4.2
unnamed: R4.1, R10.2
unnamed: D2.1 (A), D3.C, Q4.2 (S), Q5.2 (S), R3.2
unnamed: Q2.3 (C), Q4.1 (G), R1.2
unnamed: J8.2, Q4.3 (D)
unnamed: Q2.1 (B), R5.2
unnamed: D3.A, J7.2, Q2.2 (E), R8.2
unnamed: R6.1, R9.2
unnamed: R7.2, R9.1
unnamed: Q3.1 (B), R8.1
unnamed: R12.1, R15.2
unnamed: Q5.1 (G), R27.2, U1.1 (C)
unnamed: R14.2, R15.1
unnamed: R16.1, R18.2
unnamed: R17.2, R18.1
unnamed: R19.1, R21.2
unnamed: R20.2, R21.1
unnamed: R11.2, R22.2
SENSE_T: J2.2, J9.2, PAD1.1, R11.1, R13.1, U1.2 (R)

Notes on the sheet:
Thermostat
Battery switch

Board: 2 copper layers, 40.0 x 18.0 mm, 38 parts (15 on the bottom side), 25 nets.

## EAGLE design eagle/misc/heater-v1.brd

Parts:
PAD1, PAD2: 1,6/0,8
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: 100; R1206

Connections:
N1: PAD1.1, R1.2, R2.2, R3.2, R4.2, R5.1, R6.2, R7.1, R8.1, R9.1, R10.1
N2: PAD2.1, R1.1, R2.1, R3.1, R4.1, R5.2, R6.1, R7.2, R8.2, R9.2, R10.2

Board: 2 copper layers, 35.0 x 18.0 mm, 12 parts (0 on the bottom side), 2 nets.

## EAGLE design eagle/tracker/tracker-25mm-full.brd

Parts:
C1, C8: 10n; C603
C2: 10u; EIA3216
C3, C6, C7, C9, C10, C12, C13, C14, C15, C17, C18: 100n; C603
C4, C5, C11, C16, C19, C20: 1u; C603
D1: RED; R0805
D2: GREEN; R0805
D3: YELLOW; R0805
FB1, FB3: FERRITE_0805; _0805
J1: BATT; JST-2-PTH-VERT
J2: WM9734TR-ND; USB-B-MICRO-SMD_VERT
J3: BATT_PYRO; JST-2-PTH-VERT
J4: PROG; JST-4-PTH-VERT
J6: UART; JST-3-PTH-VERT
JP1: BYPASS2; PAD-JUMPER-2-NO_YES_SILK
JP2: CFG1; PAD-JUMPER-2-NO_YES_SILK
JP3: CFG2; PAD-JUMPER-2-NO_YES_SILK
JP5: LDO_BYPASS; PAD-JUMPER-2-NO_YES_SILK
L1: NF; R0603
M1: UBLOX-NEO-M8; UBLOX-NEO
M2: HOPE-RFM98W; MOD-RFM95
M4: UBLOX-MAX-M8; UBLOX-MAX
PAD1, PAD2: SMD5; SMD2,54-5,08
Q1, Q2, Q3, Q4: PMV30UN2; SOT23-3
R1, R7, R19, R26, R30: 1k; R0603
R2, R5, R10, R11, R13, R16, R17, R18, R21, R22, R23, R24, R25: 100k; R0603
R3, R4, R8, R9, R15: 3.3k; R0603
R6, R27: 470; R0603
R12, R28, R29: 27; R0603
R14, R20: 10k; R0603
R31: *2.0k; R0603
SG1: F/TMB
U1: MCP73831; SOT23-5
U2: MIC5504-3.3/LP3985IM5-3.3; SOT23-5
U3: A25L010A/SST26VF016B; SOP08
U4: MAG3110FCR1; DFN200X200X90-10N
U5: LSM6DS33; TFLGA16L
U6: MIC5504-2.8/LP3985IM5-2.7; SOT23-5
U7: H3LIS100DL; QFN16_3X5
U8: STM32L063C; LQFP48
U10: MPL3115A2; LGA8
X2, X6: COAX; MMCX-J-P-X-ST-EM1-MKT
X4: MICROMATCH-8

Connections:
3.3V: C2.A (+), C3.2, C5.2, C7.2, C15.2, C16.2, C17.2, FB1.2, FB3.1, JP2.2, JP3.2, JP5.2, R3.2, R4.2, R5.1, R9.2, R14.2, U2.5 (OUT), U3.3 (WP), U3.7 (HOLD), U3.8 (VCC), U4.2 (VDD), U4.8 (VDDIO), U5.1 (VDD_IO), U5.4 (SDO), U5.5 (CS), U5.16 (VDD), U6.1 (IN), U6.3 (EN), U7.P1 (VDD_IO), U7.P7 (SDO/SA0), U7.P8 (CS), U7.P14 (VDD), U7.P15 (RES2), U8.1 (VLCD/VBAT), U8.9 (VDDA), U8.24 (VDD1), U8.36 (VDDIO2/PF7), U8.48 (VDD2), U10.1 (VDD), U10.4 (VDDIO)
!FLASH_CS: R14.1, U3.1 (CS), U8.38 (PA15)
!GPS_RST: M4.9 (!RESET), R15.1
!RFM_RST: M2.6 (!RESET), U8.30 (PA9)
!RFM_SS: M2.5 (!SS), U8.31 (PA10)
!RST: C1.2, J4.4, R9.1, U8.7 (NRST)
BUZZER: R7.1, U8.28 (PB15)
DBG_RX: J6.2, U8.13 (PA3)
DBG_TX: J6.3, U8.12 (PA2)
D_PYRO1: R1.1, R18.1, U8.18 (PB0)
D_PYRO2: R17.1, R19.1, U8.19 (PB1)
GND: C1.1, C2.C (-), C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, D1.2 (C), D2.2 (C), J1.1, J2.GND, J2.P1 (SHIELD), J2.P2 (SHIELD), J2.P3 (SHIELD), J3.1, J4.1, J6.1, L1.1, M1.7 (VDDUSB), M1.10 (GND), M1.12 (GND), M1.13 (GND), M1.22 (V_BCKP), M1.24 (GND), M2.1 (GND1), M2.8 (GND2), M2.10 (GND3), M4.1 (GND), M4.6 (V_BCKP), M4.10 (GND), M4.12 (GND), Q1.2 (S), Q4.2 (S), R2.1, R13.1, R17.2, R18.2, R23.1, R24.1, R25.1, R31.1, U1.2 (VSS), U2.2 (GND), U3.4 (GND), U4.5 (GND_2), U4.10 (GND), U5.8 (RES1), U5.9 (RES2), U5.10 (RES3), U5.11 (RES4), U5.12 (GND1), U5.13 (GND2), U5.15 (RES5), U6.2 (GND), U7.P5 (GND1), U7.P10 (RES1), U7.P12 (GND2), U7.P13 (GND3), U7.P16 (GND4), U8.8 (VSSA), U8.23 (VSS1), U8.35 (VSS/PF6), U8.44 (BOOT0), U8.47 (VSS2), U10.3 (GND), X2.2@1 (GND), X2.2@2 (GND)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
GPS_PPS: M1.3 (TIMEPULSE), M4.4 (TIMEPULSE), R27.2, U8.29 (PA8)
GPS_RXD: M1.20 (TXD/MISO), M4.2 (TXD), U8.43 (PB7)
GPS_TXD: M1.21 (RXD/MOSI), M4.3 (RXD), U8.42 (PB6)
GPS_VCC: C9.2, C18.2, FB3.2, M1.2 (D_SEL), M1.23 (VCC), M4.7 (VCC_IO), M4.8 (VCC), R15.2
LED: R6.2, U8.25 (PB12)
MISO: M2.2 (MISO), U3.2 (SO), U8.40 (PB4)
MOSI: M2.3 (MOSI), U3.5 (SI), U8.41 (PB5)
unnamed: L1.2, M1.11 (RF_IN), M4.11 (RF_IN), X2.1
unnamed: D2.1 (A), R27.1
unnamed: Q1.1 (G), R2.2, R7.2
unnamed: PAD2.1, Q1.3 (D), SG1.-
unnamed: C6.2, FB1.1, M2.13 (3.3V)
unnamed: M1.8 (!RESET), R8.1
unnamed: M1.9 (VCC_RF), R8.2
unnamed: C8.2, U2.4 (BP)
unnamed: Q2.2 (S), Q3.2 (S), Q4.3 (D)
unnamed: D1.1 (A), R6.1
unnamed: Q2.1 (G), R19.2
unnamed: C11.2, R12.1, U6.5 (OUT)
unnamed: C13.2, U4.1 (CAP-A)
unnamed: C14.2, U4.4 (CAP-R)
unnamed: C12.2, JP2.1, U10.2 (CAP)
unnamed: Q3.1 (G), R1.2
unnamed: J2.D+, R29.2
unnamed: J2.D-, R28.2
unnamed: JP3.1, U10.5 (INT2)
unnamed: Q4.1 (G), R5.2, R20.1, R26.1
unnamed: D3.2 (C), R30.2
unnamed: M2.9 (ANT), X6.1
unnamed: R30.1, U1.1 (STAT)
unnamed: R31.2, U1.5 (PRG)
PYRO1_OUT: Q2.3 (D), R21.1, X4.4
PYRO2_OUT: Q3.3 (D), R22.1, X4.2
RFM_DIO0: M2.14 (DIO0), U8.21 (PB10)
RFM_DIO2: M2.16 (DIO2), U8.2 (PC13)
SAFE: R20.2, X4.6
SCK: M2.4 (SCK), U3.6 (SCK), U8.39 (PB3)
SCL: R3.1, U4.7 (SCL), U5.2 (SCL), U7.P4 (SCK/SCL), U8.45 (PB8), U10.8 (SCL)
SDA: R4.1, U4.6 (SDA), U5.3 (SDA), U7.P6 (SDI/SDA), U8.46 (PB9), U10.7 (SDA)
SENSE_ARM: R26.2, U8.17 (PA7)
SENSE_P1: R22.2, R25.2, U8.14 (PA4)
SENSE_P2: R21.2, R24.2, U8.15 (PA5)
SENSE_VBATT: C10.2, R11.1, R13.2, U8.10 (PA0)
SENSE_VPYRO: R16.2, R23.2, U8.11 (PA1)
SHDN: R10.1, U2.3 (EN), X4.8
SWCLK: J4.3, U8.37 (PA14)
SWDIO: J4.2, U8.34 (PA13)
USB_DM: R28.1, U8.32 (PA11)
USB_DP: R29.1, U8.33 (PA12)
VDD_USB: C19.2, D3.1 (A), J2.VBUS, U1.4 (VDD)
V_BATT: C4.2, C20.2, J1.2, JP1.1, JP5.1, PAD1.1, R10.2, R11.2, SG1.+, U1.3 (BAT), U2.1 (IN)
V_PYRO: J3.2, JP1.2, R12.2, R16.1, X4.1, X4.3

Notes on the sheet:
75uA in Inactive State 15uA Backup battery current
0.2uA in Standby Mode 1.5uA in Idle Mode
Barometer (optional)
SPI Flash (optional)
SUPERCAP HERE (PACKAGE BY JST CONNECTOR)
MPL3115A2 CFG1=open CFG2=open MPL115A2 CFG1=open CFG2=short MS5607-02 CFG1=short CFG2=short

Board: 2 copper layers, 75.2 x 28.0 mm, 88 parts (38 on the bottom side), 64 nets.

Notices in the files:
eagle/relay_shield/mosfet-shield-v2.brd:
(c) 2017 Karlis Goba
eagle/tracker/tracker-25mm-full.brd:
(c) 2018 Karlis Goba
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder_v3: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
