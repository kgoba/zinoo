# Repository kgoba/zinoo (continued)

## EAGLE design eagle/tracker/tracker-balloon-full.brd

Parts:
C1: 10n; C603
C2: 10u; EIA3216
C3, C6, C7, C9, C10, C13, C14, C15, C19: 100n; C603
C4, C5, C8, C11, C16, C17, C18: 1u; C603
C12: CPOL-EUE3.5-8; E3,5-8
D1, D6, D7, D8, D9, D10, D11, D12, D13, D14: LED0805; R0805
D3, D4, D5: DIODE-ZENER-SOD323; SOD-323
FB1, FB3: FERRITE_0805; _0805
J1: BATT; JST-2-PTH-VERT
J2: USB_MINI-B_SMT; USB-MINIB
J3: BATT AUX; SCREWTERMINAL-3.81MM-2
J4: SWD; JST-4-PTH-VERT
J5: MICRO-SD_CARD_SOCKET; MICRO-SD-SOCKET
J6: UART; JST-3-PTH-VERT
J7: BATT GSM; JST-2-PTH-VERT
J8: AUX1; SCREWTERMINAL-3.81MM-2
J9: AUX2; SCREWTERMINAL-3.81MM-2
J10: AUX3; SCREWTERMINAL-3.81MM-2
J11, J12: M2-3.81MM; SCREWTERMINAL-3.81MM-2
J13: INTERN; MICROMATCH-4
J14: THERMO; JST-3-PTH-VERT
J15: EXTERN; MICROMATCH-6
JP2, JP3, JP4, JP6: PINHD-1X3; 1X03
L1A: L-0603; R0603
M1: UBLOX-NEO-M8; UBLOX-NEO
M2: HOPE-RFM98W; HOPE-RFM
M3: SIM800L-MODULE; SIM800L
M4: UBLOX-MAX-M8; UBLOX-MAX
Q1, Q2, Q3, Q4, Q7, Q8, Q10, Q12: MOSFET-N-SOT23-3; SOT23-3
Q5, Q6, Q9, Q11: MOSFET-P-SOT23-3; SOT23-3
R1, R6, R7, R17, R18, R19, R26, R28, R29, R30, R31, R32, R33, R35, R36, R38, R39, R40, R41, R42, R43, R44, R45, R48, R50, R52, R53, R54, R55, R56: 1k; R0603
R2, R9, R14, R20, R51: 10k; R0603
R3, R4: 4k7; R0603
R5, R10, R11, R13, R16, R21, R22, R23, R24, R25, R27, R34, R37, R46, R47, R49: 100k; R0603
R8, R15: 3.3k; R0603
R12: 22; R0603
R57: 100; R0603
SV1: ML6
U1: MS5637-02; MS5637
U2, U6: VREG-5PIN-SOT23; SOT23-5
U3: A25L010A; SOP08
U4: MAG3110FCR1; DFN200X200X90-10N
U5: LSM6DS33; TFLGA16L
U7, U8: MCP73831; SOT23-5
U9: STM32L072R; LQFP64
X2, X3, X5: SMACONNECTOR; SMA90_DIP
X4: ANTENNA-PATCH-12X12; ANT-PATCH-12X12

Connections:
3.3V: C2.A (+), C3.2, C5.2, C7.2, C15.2, FB1.2, FB3.1, J5.VCC, R3.2, R4.2, R5.1, R9.2, R12.2, R14.2, R27.2, R31.1, U1.1 (VDD), U2.5 (OUT), U3.3 (WP), U3.7 (HOLD), U3.8 (VCC), U4.2 (VDD), U4.8 (VDDIO), U5.1 (VDD_IO), U5.4 (SDO), U5.5 (CS), U5.16 (VDD)
!FLASH_CS: J5.CS (!CS), R14.1, U3.1 (CS)
!GSM_RST: M3.3 (!RST)
!RFM_RST: M2.6 (!RESET)
!RFM_SS: M2.5 (!SS)
!RST: C1.2, J4.2, R9.1
ARM_SENSE: R26.2
BUZZER_ON: R2.2, R7.1
DBG_RX: J6.2
DBG_TX: J6.3
DO_SRV1: R39.1
DO_SRV2: R40.1
DO_SRV3: R41.1
DO_SRV4: R42.1
D_LOAD1: R32.1, R43.1
D_LOAD2: R35.1, R44.1
D_LOAD3: R38.1, R45.1
GND: C1.1, C2.C (-), C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.-, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, D1.2 (C), D6.2 (C), D7.2 (C), D8.2 (C), D9.2 (C), D10.2 (C), J1.1, J2.GND, J3.1, J4.1, J5.GND, J5.GND1 (SHIELD), J5.GND3 (SHIELD), J6.1, J7.1, J8.1, J9.1, J10.1, JP2.3, JP3.3, JP4.3, JP6.3, L1A.1, M1.7 (VDDUSB), M1.10 (GND), M1.12 (GND), M1.13 (GND), M1.22 (V_BCKP), M1.24 (GND), M2.1 (GND1), M2.8 (GND2), M2.10 (GND3), M3.6 (GND), M4.1 (GND), M4.6 (V_BCKP), M4.10 (GND), M4.12 (GND), Q1.2 (S), Q4.2 (S), Q7.2 (S), Q8.2 (S), Q10.2 (S), Q12.2 (S), R2.1, R13.1, R23.1, R24.1, R25.1, R49.1, R50.1, R51.1, R54.1, R55.1, U1.4 (GND), U2.2 (GND), U3.4 (GND), U4.5 (GND_2), U4.10 (GND), U5.8 (RES1), U5.9 (RES2), U5.10 (RES3)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
GPS_PPS: M1.3 (TIMEPULSE), M4.4 (TIMEPULSE)
GPS_RXD: M1.20 (TXD/MISO), M4.2 (TXD)
GPS_TXD: M1.21 (RXD/MOSI), M4.3 (RXD)
GPS_VCC: C9.2, FB3.2, M1.2 (D_SEL), M1.23 (VCC), M4.7 (VCC_IO), M4.8 (VCC), R15.2
GSM_ON: R48.1, R49.2
GSM_RXD: M3.5 (TXD)
GSM_TXD: M3.4 (RXD)
LED_STATUS: R6.2
MISO: J5.DO, M2.2 (MISO), U3.2 (SO)
MOSI: J5.DI, M2.3 (MOSI), U3.5 (SI)
unnamed: L1A.2, M1.11 (RF_IN), M4.11 (RF_IN), X3.ANTENNA (ANT), X4.FEED
unnamed: C11.2, R12.1, U6.1 (IN), U6.3 (EN)
unnamed: Q1.1 (G), R7.2
unnamed: Q12.1 (G), R48.2
unnamed: C6.2, FB1.1, M2.13 (3.3V)
unnamed: M1.8 (!RESET), R8.1
unnamed: M1.9 (VCC_RF), R8.2
unnamed: C8.2, U2.4 (BP)
unnamed: D11.2 (C), Q2.2 (S), Q3.2 (S), Q4.3 (D)
unnamed: D1.1 (A), R6.1
unnamed: Q2.1 (G), R19.2
unnamed: C13.2, U4.1 (CAP-A)
unnamed: C14.2, U4.4 (CAP-R)
unnamed: M4.9 (!RESET), R15.1
unnamed: Q3.1 (G), R1.2
unnamed: M3.1 (ANT), X5.ANTENNA (ANT)
unnamed: D12.2 (C), R50.2
unnamed: J2.D-, R28.2
unnamed: Q4.1 (G), R5.2, R20.1, R26.1
unnamed: J2.D+, R29.2
unnamed: M2.9 (ANT), X2.ANTENNA (ANT)
unnamed: JP6.1, R42.2
unnamed: D3.A, Q5.1 (G), R30.1, R34.1
unnamed: Q8.3 (D), R30.2
unnamed: Q8.1 (G), R32.2
unnamed: J8.2, Q5.3 (D)
unnamed: D6.1 (A), R43.2
unnamed: JP4.1, R41.2
unnamed: D4.A, Q6.1 (G), R33.1, R37.1
unnamed: Q7.3 (D), R33.2
unnamed: Q7.1 (G), R35.2
unnamed: J9.2, Q6.3 (D)
unnamed: JP3.1, R40.2
unnamed: JP2.1, R39.2
unnamed: D5.A, Q9.1 (G), R36.1, R46.1
unnamed: Q10.3 (D), R36.2
unnamed: Q10.1 (G), R38.2
unnamed: J10.2, Q9.3 (D)
unnamed: D9.1 (A), R17.2
unnamed: D8.1 (A), R45.2
unnamed: D7.1 (A), R44.2
unnamed: D10.1 (A), R18.2
unnamed: D11.1 (A), R31.2
unnamed: D12.1 (A), M3.2 (VCC), Q11.3 (D)
unnamed: Q11.1 (G), Q12.3 (D), R47.1
unnamed: M3.11 (DTR), R51.2
unnamed: D13.1 (A), R52.2
unnamed: D14.1 (A), R53.2
unnamed: D14.2 (C), U7.1 (STAT)
unnamed: D13.2 (C), U8.1 (STAT)
unnamed: R54.2, U8.5 (PRG)
unnamed: R55.2, U7.5 (PRG)
NTC_EXT: C19.2, R27.1, R56.2
NTC_SENSE: R56.1
PYRO1_ON: R17.1, R19.1
PYRO1_OUT: J11.1, Q2.3 (D), R21.1
PYRO1_SENSE: R21.2, R24.2
PYRO2_ON: R1.1, R18.1
PYRO2_OUT: J12.1, Q3.3 (D), R22.1
PYRO2_SENSE: R22.2, R25.2
RFM_DIO0: M2.14 (DIO0)
SAFE: R20.2
SCK: J5.SCLK (SCK), M2.4 (SCK), U3.6 (SCK)
SCL: R3.1, U1.3 (SCL), U4.7 (SCL), U5.2 (SCL)
SDA: R4.1, U1.2 (SDA), U4.6 (SDA), U5.3 (SDA)
SHDN: R10.1, U2.3 (EN)
SWCLK: J4.3
SWDIO: J4.4
USB_DM: R28.1, U9.44 (PA11)
USB_DP: R29.1, U9.45 (PA12)
VCC_PYRO: C12.+, J11.2, J12.2, R16.1, U6.5 (OUT)
V_BATT: C4.2, C17.2, J1.2, R10.2, R11.2, R57.2, U2.1 (IN), U8.3 (BAT)
V_BATT_SENSE: C10.2, R11.1, R13.2
V_BUZZER+: R57.1
V_BUZZER-: Q1.3 (D)
V_GSM: C18.2, J7.2, Q11.2 (S), R47.2, U7.3 (BAT)
V_LOAD: D3.C, D4.C, D5.C, J3.2, Q5.2 (S), Q6.2 (S), Q9.2 (S), R34.2, R37.2, R46.2
V_PYRO_SENSE: R16.2, R23.2
V_SERVO: JP2.2, JP3.2, JP4.2, JP6.2
V_USB: C16.2, J2.VBUS, R52.1, R53.1, U7.4 (VDD), U8.4 (VDD)

Notes on the sheet:
75uA in Inactive State 15uA Backup battery current
0.2uA in Standby Mode 1.5uA in Idle Mode
Barometer (optional)
SPI Flash (optional)
Servo PWM outputs
Load switches
ARMED
P2 ACT
P1 ACT
GSM ON

Board: 2 copper layers, 104.0 x 90.0 mm, 141 parts (51 on the bottom side), 88 nets.

## Code that names these connections

File firmware/lora-ground/src/config.h:

#pragma once

#define FREQUENCY_MHZ 434.25        // Transmit center frequency, MHz

#ifndef TX_POWER_DBM
#define TX_POWER_DBM   5            // Transmit power in dBm (range +5 .. +23)
#endif

/// Select LoRa mode (speed and bandwidth):
// * Bw125Cr45Sf128	    ///< Bw = 125 kHz, Cr = 4/5, Sf = 128chips/symbol, CRC on. Default medium range
// * Bw500Cr45Sf128	    ///< Bw = 500 kHz, Cr = 4/5, Sf = 128chips/symbol, CRC on. Fast+short range
// * Bw31_25Cr48Sf512   ///< Bw = 31.25 kHz, Cr = 4/8, Sf = 512chips/symbol, CRC on. Slow+long range
// * Bw125Cr48Sf4096    ///< Bw = 125 kHz, Cr = 4/8, Sf = 4096chips/symbol, CRC on. Slow+long range
#define MODEM_MODE RH_RF95::Bw125Cr45Sf128

#define LORA_MAX_MESSAGE_LEN    80

#define LORA_RST_PIN          9       // Hardwired on the LoRa/GPS shield

#ifdef LORA_MODIFIED
#define LORA_CS_PIN           3       // Modified on the LoRa/GPS shield!!!
#define PPS_PIN               8       // Modified on the LoRa/GPS shield!!!
#else
#define LORA_CS_PIN          10       // Original configuration on the LoRa/GPS shield
#define PPS_PIN              A3       // Original configuration on the LoRa/GPS shield
#endif

#define GPS_UPDATE_INTERVAL 60      // Time syncing interval (seconds)
#define UPLINK_INTERVAL     1

//#define LOCAL_TIME_OFFSET_HOURS     2

#ifdef WITH_BUTTONS
#define BUTTON1_PIN			A5
#define BUTTON2_PIN			A4
#define BUTTON3_PIN			A3
#define BUTTON4_PIN			A2
#define BUTTON5_PIN			A1
#define BUTTON6_PIN			A0
#endif

#ifdef WITH_TFT
#define TFT_CS_PIN    7
#define TFT_DC_PIN    6
#define TFT_RST_PIN   5
#endif

#ifdef WITH_LCD
#define SWITCH1_PIN      A2
#define SWITCH2_PIN      A3
#endif

#if defined(WITH_TFT) || defined(WITH_LCD)
#define WITH_DISPLAY
#endif

#define TONE_FREQUENCY		1000
#define	TONE_PERIOD_DEFAULT	16000
#define	TONE_PERIOD_MIN		15000
#define	TONE_PERIOD_MAX		17000
#define TONE_PLL_THRESHOLD	4000

File zinoo-lora/src/config.h:

#pragma once

#define FREQUENCY_MHZ 434.25        // Transmit center frequency, MHz
#define TX_POWER_DBM    5           // Transmit power in dBm (range +5 .. +23)

/// Select LoRa mode (speed and bandwidth):
// * Bw125Cr45Sf128	    ///< Bw = 125 kHz, Cr = 4/5, Sf = 128chips/symbol, CRC on. Default medium range
// * Bw500Cr45Sf128	    ///< Bw = 500 kHz, Cr = 4/5, Sf = 128chips/symbol, CRC on. Fast+short range
// * Bw31_25Cr48Sf512   ///< Bw = 31.25 kHz, Cr = 4/8, Sf = 512chips/symbol, CRC on. Slow+long range
// * Bw125Cr48Sf4096    ///< Bw = 125 kHz, Cr = 4/8, Sf = 4096chips/symbol, CRC on. Slow+long range
#define MODEM_MODE RH_RF95::Bw31_25Cr48Sf512

#define LORA_RST_PIN      	9       // Hardwired on the LoRa/GPS shield
#define LORA_CS_PIN			3		// Modified on the LoRa/GPS shield!!!
#define PPS_PIN             8       // Modified on the LoRa/GPS shield!!!

#define UPLINK_TIMEOUT		3000	// Milliseconds to wait for an uplink command after transmit

#ifndef CALLSIGN
#define CALLSIGN "Z_TEST"           // Payload callsign
#endif

#ifndef TIMESLOT
#define TIMESLOT 0                  // Transmit offset in seconds
#endif

#ifndef TOTAL_SLOTS
#define TOTAL_SLOTS 10              // Transmit period in seconds 
#endif

/// NTC thermistor configuration
#define NTC_PIN     0               // Analog pin number
#define NTC_T0      (273+25)        // 25C in Kelvin
#define NTC_R0      47000           // Resistance of the NTC at 25C, in ohms
#define NTC_B       2700            // B coefficient of the NTC
#define NTC_R1      10000           // Resistance of the resistor to the ground, in ohms

#define RELEASE_PIN         3       // Digital pin number (3, 4, 5, 14-16, 18-19)
#define RELEASE_ALTITUDE    10000   // Release pin will go high above this altitude (m)
#define RELEASE_SAFETIME    120     // Duration of safe mode in seconds since start (power on)

// Servo configuration
#define SERVO1_PIN	A4
#define SERVO2_PIN  A5

#define BUZZER_PIN  A2

## Commit log

2016-05-04 Added submodule
2016-05-04 Simple gitignore for AVR development
2016-05-10 Initial commit of source files
2016-05-15 Added PlatformIO project
2016-05-15 Updated PTLib
2016-05-15 Moved PTLib module to libs
2016-05-15 Updated to compile
2016-05-15 Minor updates
2016-05-15 Updated to latest version
2016-05-16 Added RTTY
2016-05-18 Initial TWI implementation
2016-05-18 Updated version
2016-05-20 Added barometer test code
2016-05-23 Added comments
2016-05-24 Moved to PTLib
2016-05-24 Added humidity sensor
2016-05-24 Version update
2016-05-24 Syntax error fix
2016-05-24 Added fixed point conversion
2016-06-04 New fixes
2016-06-04 Updated to new version
2016-06-04 Switched to branch tracking
2016-06-05 Multiple new I2C sensors
2016-06-05 Updated to newer version
2016-06-05 Removed duplicate
2016-06-09 Initial mag/acc sensor commit
2016-06-09 Renamed fixed point types
2016-06-09 Register constants
2016-06-10 Add FatFs and restructure
2016-06-10 Magnetometer updates
2016-06-22 Added fatfs
2016-06-22 RTTY decoder
2016-10-02 Minor changes
2016-10-02 Added travis.yml file
2016-10-11 Massive updates
2016-10-14 Add FSK, add GPS, add sensors
2016-10-15 New fixed point features
2016-10-16 Updated file structure
2016-10-18 Code cleanup
2016-10-22 Added buzzer error code signal
2016-10-24 Updated UKHAS packet generation
2016-11-01 Added ESP control (Test mode)
2016-11-10 Updated buzzer indication
2017-03-13 test
2017-03-13 2017.03.13. 16:58
2017-03-13 2017.03.13. 16:58 add eeprom store
2017-03-16 2017.03.16. 13:58 add voltage
2017-08-08 Moved Liepaja project to a subfolder
2017-08-08 Added LoRa code from Dragino examples
2017-08-08 Cleanup
2017-08-10 Added TinyGPS++ as a module
2017-08-10 Added Time library and updated code
2017-08-10 Moved checksum calculation to ground station
2017-08-12 Added Habhub upload script, added GPS to Lora ground station
2017-08-12 Added setup instructions
2017-08-13 Added distance calculation
2017-08-13 Added temperature sensor
2017-08-13 Switched to TinyGPS++
2017-08-14 Updated GPS parsing and added NTC
2017-08-18 Minor fix
2017-08-29 Added experimental TDOA solver
2017-08-30 Corrected environment names
2017-08-30 Added sudo to pip commands
2017-08-30 Added listener position reporting to habhub (not tested)
2017-08-30 Reverse for now
2017-08-31 Fixes in Habitat upload script (listener reporting)
2017-08-31 Minor code updates
2017-09-01 Update README.md
    add "requirements.txt" command
2017-09-01 Added restkit dependency
2017-09-01 Fixed Habitat upload
2017-09-02 Moved library modules to a common directory
2017-09-02 Moved configuration to a separate file
2017-09-02 Added TOA reporting
2017-09-02 Compilation error fix
2017-09-06 Added EEPROM dump to MicroPeak dump converter
2017-11-04 custom version for g48 spacetech2017
2017-11-05 Updates for iDO balloon demo
2017-12-28 Added buzzer
2017-12-28 Added MicroPeak report convertor
2017-12-28 Structural update
2018-01-04 Added eagle files
2018-01-05 Added Raspberry camera scripts
2018-01-14 Added TFT display
2018-01-14 Small improvements
2018-01-14 Separated display functions
2018-01-20 Added pyro sensing and uBlox MAX support
2018-01-20 Bumped up library versions
2018-01-25 File reorganization
2018-01-25 Stability fixes and configuration options
2018-01-25 Renamed LoRa projects
2018-01-25 Added balloon/ground boards
2018-01-25 Added antenna rotator (initial code)
2018-01-30 Added uplink (not tested)
2018-01-30 Added ADC reading
2018-02-01 Updates before BALTS1 flight
2018-02-03 Changes before BALTS1 flight
2018-02-07 Added LCD test code
2018-02-07 Added UPLINK indication, bumped TX power to 23 dBm
2018-02-09 Updates to tracker
2018-02-09 Moved file
2018-02-09 Added rssi and rx count fields to packet
2018-02-09 Updates to balloon flight board
2018-02-10 Added GPS mode setting at startup
2018-02-11 Added Balloon mode setting (not tested yet)
2018-02-11 Tracker ready for order
2018-02-12 File fix
2018-02-13 Added searching for serial ports
2018-02-13 Preparation for BALTS2
2018-02-20 Added flight computer for 28mm
2018-02-20 Updated balloon board
2018-02-20 updated status string
2018-02-20 Added tests
2018-02-21 Updated ground board
2018-02-21 Added production-ready ground station
2018-02-22 Updated ground station production board
2018-02-22 Added standalone GSM tracker
2018-02-25 Updates in ground tracker (TODO)
2018-02-25 Added SIM800 test code
2018-02-26 Ground station updates
2018-03-05 Changes to LoRa tracker
2018-03-13 Minor update
2018-03-13 Added test option
2018-03-13 Added interchar timeout
2018-03-13 Changes for BALTS2
2018-03-13 Rigid body spin simulation
2018-03-13 Added BOM
2018-03-26 Added new utilities and bumped libopencm3 version
2018-03-26 Added tinysky STM32 initial code
2018-03-26 Minor changes for BALTS3
2018-03-26 Added stm32 template lib
2018-03-26 Added ignore .build/
2018-03-26 Fixed a critical bug in PCB
2018-04-02 Massive updates (I2C working, uBlox commands, etc)
2018-04-02 uBlox raw data analysis tool
2018-04-05 Working TX version of LoRa
2018-04-06 Added LoRa packet transmission
2018-04-07 New scheduler and littleFS
2018-04-10 Task scheduler, LittleFS, SPI flash and code refactor
2018-04-10 Updates for v1.01
2018-04-18 Changes before USINS-2 flights
2018-04-21 Updated documentation
2018-04-21 Added thermostat project
2018-04-22 Switched to forked copy of libopencm3 for L0 support
2018-04-22 Switched sky/ground to new LoRa settings
2018-04-22 Added gyro support
2018-04-22 Updates in utilities
2018-04-22 Added TinySky log utilities
2018-04-22 Updated thermostat
2018-04-24 Thermostat updates
2018-09-06 Fixed case-sensitive file name
